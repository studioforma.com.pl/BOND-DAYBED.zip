Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Bond - Daybed - VER4.ifc
Time: 2025-11-04T14:42:35
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (28)
Name
 | Bond - Daybed_0 - ObjectType: SketchupGroup
 | Bond - Daybed_1 - ObjectType: SketchupGroup
 | Bond - Daybed_2 - ObjectType: SketchupGroup
 | Bond - Daybed_3 - ObjectType: SketchupGroup
 | Bond - Daybed_4 - ObjectType: SketchupGroup
 | Bond - Daybed_5 - ObjectType: SketchupGroup
 | Bond - Daybed_6 - ObjectType: SketchupGroup
 | Bond - Daybed_7 - ObjectType: SketchupGroup
 | Bond - Daybed_8 - ObjectType: SketchupGroup
 | Bond - Daybed_9 - ObjectType: SketchupGroup
 | Bond - Daybed_10 - ObjectType: SketchupGroup
 | Bond - Daybed_11 - ObjectType: SketchupGroup
 | Bond - Daybed_12 - ObjectType: SketchupGroup
 | Bond - Daybed_13 - ObjectType: SketchupGroup
 | Bond - Daybed_14 - ObjectType: SketchupGroup
 | Bond - Daybed_15 - ObjectType: SketchupGroup
 | Bond - Daybed_16 - ObjectType: SketchupGroup
 | Bond - Daybed_17 - ObjectType: SketchupGroup
 | Bond - Daybed_18 - ObjectType: SketchupGroup
 | Bond - Daybed_19 - ObjectType: SketchupGroup
 | Bond - Daybed_20 - ObjectType: SketchupGroup
 | Bond - Daybed_21 - ObjectType: SketchupGroup
 | Bond - Daybed_22 - ObjectType: SketchupGroup
 | Bond - Daybed_23 - ObjectType: SketchupGroup
 | Bond - Daybed_24 - ObjectType: SketchupGroup
 | Bond - Daybed_25 - ObjectType: SketchupGroup
 | Bond - Daybed_26 - ObjectType: SketchupGroup
 | Bond - Daybed_27 - ObjectType: SketchupGroup
